# Repository takahashirenya/QX26-printed-circuit-board (continued)

## KiCad design power/power.kicad_pcb (continued)

Parts:
C5, C12: 15p; C_0402_1005Metric
C8, C11: 10u; C_0805_2012Metric
C10, C17, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29: 100n; C_0402_1005Metric
C13: 4.7u; C_0402_1005Metric_small_pads
C15: 4,7u; C_0402_1005Metric_small_pads
C18: 4.7u; C_0402_1005Metric
C19: 4,7u; C_0402_1005Metric
D1, D2: D; D_SMA
D4: LED; L_0603_1608Metric
IC1: W25Q128JVSIQTR; SOIC127P790X216-8N; Manufacturer_Part_Number W25Q128JVSIQTR
J15: ZX62M-B-5P; ZX62MB5P; Manufacturer_Part_Number ZX62M-B-5P; Mouser Part Number 798-ZX62M-B-5P
L1: 3.3u; L_pol_2016
R3: 0; R_0402_1005Metric
R4, R5: DNF; R_0402_1005Metric
R6, R9, R10: 1k; R_0402_1005Metric
R8: 33; R_0402_1005Metric
R13, R14: 27; R_0402_1005Metric
SW1, SW2: SW_Push; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
U1: NCP1117-3.3_SOT223; SOT-223-3_TabPin2
U3: RP2350_60QFN; RP2350-QFN-60-1EP_7x7_P0.4mm_EP3.4x3.4mm_ThermalVias
Y1: ABM8-272-T3; Crystal_SMD_3225-4Pin_3.2x2.5mm; Manufacturer_Part_Number ABM8-272-T3; Mouser Part Number 815-ABM8-272-T3

Connections:
+1V1: C15.1, C17.1, C19.1, C20.1, L1.1, U3.6 (DVDD), U3.23 (DVDD), U3.39 (DVDD), U3.50 (VREG_FB)
+3V3: C10.2, C11.1, C13.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, IC1.8 (VCC), R5.2, R8.2, U1.2 (VO), U3.1 (IOVDD), U3.11 (IOVDD), U3.20 (IOVDD), U3.30 (IOVDD), U3.38 (IOVDD), U3.44 (ADC_AVDD), U3.45 (IOVDD), U3.49 (VREG_VIN), U3.53 (USB_OTP_VDD), U3.54 (QSPI_IOVDD); also elsewhere on the board
+5V: C8.1, D1.1 (K), D2.1 (K), U1.3 (VI); also elsewhere on the board
/5V_pico: D2.2 (A); also elsewhere on the board
/CAN_CS: U3.13 (GPIO9); also elsewhere on the board
/CAN_INT: U3.17 (GPIO13); also elsewhere on the board
/CAN_MISO: U3.16 (GPIO12); also elsewhere on the board
/CAN_MOSI: U3.15 (GPIO11); also elsewhere on the board
/CAN_SCK: U3.14 (GPIO10); also elsewhere on the board
/CS: U3.28 (GPIO17); also elsewhere on the board
/ELE: U3.5 (GPIO3); also elsewhere on the board
/ELE_ADC: U3.42 (GPIO28_ADC2); also elsewhere on the board
/LAD: U3.7 (GPIO4); also elsewhere on the board
/LAD_ADC: U3.43 (GPIO29_ADC3); also elsewhere on the board
/L_GEAR: U3.4 (GPIO2); also elsewhere on the board
/L_HAT: U3.3 (GPIO1); also elsewhere on the board
/MISO: U3.27 (GPIO16); also elsewhere on the board
/MOSI: U3.31 (GPIO19); also elsewhere on the board
/PWM_SPARE1: U3.8 (GPIO5); also elsewhere on the board
/PWM_SPARE2: U3.9 (GPIO6); also elsewhere on the board
/P_switch: U3.37 (GPIO25); also elsewhere on the board
/R_GEAR: U3.36 (GPIO24); also elsewhere on the board
/R_HAT: U3.35 (GPIO23); also elsewhere on the board
/SCK: U3.29 (GPIO18); also elsewhere on the board
/rp2350A/GPIO0: R4.1, U3.2 (GPIO0)
/rp2350A/QSPI_SCLK: IC1.6 (CLK), U3.56 (QSPI_SCLK)
/rp2350A/QSPI_SD0: IC1.5 (DI_(IO0)), U3.57 (QSPI_SD0)
/rp2350A/QSPI_SD1: IC1.2 (DO_(IO1)), U3.59 (QSPI_SD1)
/rp2350A/QSPI_SD2: IC1.3 (~WP_(IO2)), U3.58 (QSPI_SD2)
/rp2350A/QSPI_SD3: IC1.7 (~HOLD_OR_RESET_(IO3)), U3.55 (QSPI_SD3)
/rp2350A/QSPI_SS: R3.2, R10.1, U3.60 (QSPI_SS)
/rp2350A/USB_D+: J15.3, R13.1
/rp2350A/USB_D-: J15.2, R14.1
/rp2350A/XIN: C5.1, U3.21 (XIN), Y1.1 (CRYSTAL_1)
/rp2350A/XOUT: R6.1, U3.22 (XOUT)
/rp2350A/~USB_BOOT: R10.2, SW1.2
GND: C5.2, C8.2, C10.1, C11.2, C12.2, C13.2, C15.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, D4.1 (K), IC1.4 (GND), J15.5, J15.MP1, J15.MP2, J15.MP3, J15.MP4, J15.MP5, J15.MP6, R9.2, SW1.1, U1.1 (GND), U3.47 (VREG_PGND), U3.61 (GND), Y1.2 (GND_1), Y1.4 (GND_2); also elsewhere on the board
unnamed: D1.2 (A), J15.1
unnamed: D4.2 (A), U3.33 (GPIO21)
unnamed: IC1.1 (~CS), R3.1, R4.2, R5.1
unnamed: R9.1, SW2.1
unnamed: SW2.2, U3.26 (RUN)
unnamed: R14.2, U3.51 (USB_DM)
unnamed: R13.2, U3.52 (USB_DP)
unnamed: C18.1, R8.1, U3.46 (VREG_AVDD)
unnamed: L1.2, U3.48 (VREG_LX)
unnamed: C12.1, R6.2, Y1.3 (CRYSTAL_2)

Notes on the sheet:
power

Parts:
C30, C31, C32, C33, C34, C35, C36, C37: 10u; C_0805_2012Metric
D3: D; D_P600_R-6_P7.62mm_Vertical_AnodeUp
J14: 電源入力; JST_VH_B2P-VH-FB-B_1x02_P3.96mm_Vertical
U4, U5, U6, U7: NCP1117-5.0_SOT223; SOT-223-3_TabPin2

Connections:
+8V: C30.1, C31.1, C32.1, C33.1, D3.1 (K), U4.3 (VI), U5.3 (VI), U6.3 (VI), U7.3 (VI); also elsewhere on the board
/5V_base: C34.1, U4.2 (VO); also elsewhere on the board
/5V_logger: C35.1, U5.2 (VO); also elsewhere on the board
/5V_pico: C37.1, U7.2 (VO); also elsewhere on the board
/5V_tail: C36.1, U6.2 (VO); also elsewhere on the board
GND: C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, J14.1, U4.1 (GND), U5.1 (GND), U6.1 (GND), U7.1 (GND); also elsewhere on the board
unnamed: D3.2 (A), J14.2

Parts:
C6, C9: 22p; C_0603_1608Metric
C7: 10μF; C_0805_2012Metric
C14, C16: 100n; C_0603_1608Metric
IC2: TJA1050T; SOIC127P600X175-8N; Manufacturer_Part_Number TJA1050T; Mouser Part Number N/A
J13: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
R7: 10k; R_0603_1608Metric
R11: DNF; R_0603_1608Metric
R12: 120; R_0603_1608Metric
U2: MCP2515-xSO; SOIC-18W_7.5x11.6mm_P1.27mm
Y2: ABLS-8.000MHZ-12-B-4-Y-T; ABLS8000MHz12B4YT; Manufacturer_Part_Number ABLS-8.000MHZ-12-B-4-Y-T; Mouser Part Number 815-LS8000MHZ12B4YT

Connections:
+5V: C7.1, C14.1, C16.2, IC2.3 (VCC), R7.2, U2.18 (VDD); also elsewhere on the board
/CAN/RXCAN: IC2.4 (RXD), U2.2 (RXCAN)
/CAN/TXCAN: IC2.1 (TXD), U2.1 (TXCAN)
/CAN_CS: U2.16 (~CS); also elsewhere on the board
/CAN_H: IC2.7 (CANH), J13.2, R11.1; also elsewhere on the board
/CAN_INT: U2.12 (~INT); also elsewhere on the board
/CAN_L: IC2.6 (CANL), J13.1, R12.2; also elsewhere on the board
/CAN_MISO: U2.15 (SO); also elsewhere on the board
/CAN_MOSI: U2.14 (SI); also elsewhere on the board
/CAN_SCK: U2.13 (SCK); also elsewhere on the board
GND: C6.2, C7.2, C9.2, C14.2, C16.1, IC2.2 (GND), IC2.8 (S), U2.9 (VSS); also elsewhere on the board
unnamed: R11.2, R12.1
unnamed: C9.1, U2.8 (OSC1), Y2.2
unnamed: C6.1, U2.7 (OSC2), Y2.1
unnamed: R7.1, U2.17 (~RESET)

Notes on the sheet:
水晶発振子を使うこと。

Board: 2 copper layers, 91.3 x 97.0 mm, 81 parts (0 on the bottom side), 60 nets.

## Commit log (part)

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2025-12-04 25/12/04
2025-12-05 25/12/05
2025-12-05 25/12/05/1234
2025-12-05 25/12/05/1636
2025-12-05 25/12/05/1637
2025-12-05 2025/12/05/1722
    初めてのコミット
2025-12-08 25/12/08/1749
2025-12-08 2025/12/08/1826
2025-12-09 2025/12/09
2025-12-10 25/12/10/1830
2025-12-12 12/12
2025-12-22 12/22
    12/22
2026-02-11 2026/02/11/1853
2026-02-11 2026/02/11/2106
2026-02-12 2026/02/12/1628
2026-02-12 2026/02/12/1841
2026-02-12 2026/02/12/1907
2026-02-15 2026/02/15
2026-02-23 2026/02/23
2026-02-24 2026/02/24/1620
2026-02-24 2026/02/24/1820
2026-03-30 202603301205
2026-04-01 2026/04/01
2026-04-05 2026/04/05
2026-04-06 20260406
