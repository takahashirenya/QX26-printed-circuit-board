# Repository takahashirenya/QX26-printed-circuit-board

## KiCad design pitot_tube/pitot_tube.kicad_pcb

Parts:
C29, C30: 10u; C_0805_2012Metric
J1: RJ45_Shielded; RJ45_Amphenol_RJHSE538X
J7: 電源入力; JST_VH_B2P-VH-FB-B_1x02_P3.96mm_Vertical
R16, R17: 4.4k; R_0201_0603Metric
U7: NCP1117-5.0_SOT223; SOT-223-3_TabPin2

Connections:
+3V3: R16.1, R17.2; also elsewhere on the board
/CAN_H: J1.1; also elsewhere on the board
/CAN_L: J1.2; also elsewhere on the board
/LAN_5V: J1.4, J1.6, J1.8; also elsewhere on the board
/SCL: R16.2; also elsewhere on the board
/SDA: R17.1; also elsewhere on the board
/imput_5V: C30.1, U7.2 (VO); also elsewhere on the board
GND: C29.2, C30.2, J1.3, J1.5, J1.7, J1.SH, J7.1, U7.1 (GND); also elsewhere on the board
unnamed: C29.1, J7.2, U7.3 (VI)

Parts:
C3, C7: 15p; C_0402_1005Metric
C4, C6: 10u; C_0805_2012Metric
C5, C10, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22: 100n; C_0402_1005Metric
C8: 4.7u; C_0402_1005Metric_small_pads
C9: 4,7u; C_0402_1005Metric_small_pads
C11: 4.7u; C_0402_1005Metric
C12: 4,7u; C_0402_1005Metric
D1, D2, D3: D; D_SMA
IC1: W25Q128JVSIQTR; SOIC127P790X216-8N; Manufacturer_Part_Number W25Q128JVSIQTR
J4: USB_B_Micro; USB_Micro-B_Amphenol_10103594-0001LF_Horizontal
L1: 3.3u; L_pol_2016
R1: 0; R_0402_1005Metric
R2, R3: DNF; R_0402_1005Metric
R4, R6, R7: 1k; R_0402_1005Metric
R5: 33; R_0402_1005Metric
R8, R9: 27; R_0402_1005Metric
SW1, SW2: SW_Push; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
U2: NCP1117-3.3_SOT223; SOT-223-3_TabPin2
U3: RP2350_60QFN; RP2350-QFN-60-1EP_7x7_P0.4mm_EP3.4x3.4mm_ThermalVias
Y1: ABM8-272-T3; Crystal_SMD_3225-4Pin_3.2x2.5mm; Manufacturer_Part_Number ABM8-272-T3; Mouser Part Number 815-ABM8-272-T3

Connections:
+1V1: C9.1, C10.1, C12.1, C13.1, L1.1, U3.6 (DVDD), U3.23 (DVDD), U3.39 (DVDD), U3.50 (VREG_FB)
+3V3: C5.2, C6.1, C8.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, IC1.8 (VCC), R3.2, R5.2, U2.2 (VO), U3.1 (IOVDD), U3.11 (IOVDD), U3.20 (IOVDD), U3.30 (IOVDD), U3.38 (IOVDD), U3.44 (ADC_AVDD), U3.45 (IOVDD), U3.49 (VREG_VIN), U3.53 (USB_OTP_VDD), U3.54 (QSPI_IOVDD); also elsewhere on the board
+5V: C4.1, D1.1 (K), D2.1 (K), D3.1 (K), U2.3 (VI); also elsewhere on the board
/CS: U3.13 (GPIO9); also elsewhere on the board
/INT: U3.17 (GPIO13); also elsewhere on the board
/LAN_5V: D2.2 (A); also elsewhere on the board
/MISO: U3.16 (GPIO12); also elsewhere on the board
/MOSI: U3.15 (GPIO11); also elsewhere on the board
/SCK: U3.14 (GPIO10); also elsewhere on the board
/SCL: U3.10 (GPIO7); also elsewhere on the board
/SDA: U3.9 (GPIO6); also elsewhere on the board
/imput_5V: D3.2 (A); also elsewhere on the board
/rp2350/GPIO0: R2.1, U3.2 (GPIO0)
/rp2350/QSPI_SCLK: IC1.6 (CLK), U3.56 (QSPI_SCLK)
/rp2350/QSPI_SD0: IC1.5 (DI_(IO0)), U3.57 (QSPI_SD0)
/rp2350/QSPI_SD1: IC1.2 (DO_(IO1)), U3.59 (QSPI_SD1)
/rp2350/QSPI_SD2: IC1.3 (~WP_(IO2)), U3.58 (QSPI_SD2)
/rp2350/QSPI_SD3: IC1.7 (~HOLD_OR_RESET_(IO3)), U3.55 (QSPI_SD3)
/rp2350/QSPI_SS: R1.2, R7.1, U3.60 (QSPI_SS)
/rp2350/USB_D+: J4.3 (D+), R8.1
/rp2350/USB_D-: J4.2 (D-), R9.1
/rp2350/XIN: C3.1, U3.21 (XIN), Y1.1 (CRYSTAL_1)
/rp2350/XOUT: R4.1, U3.22 (XOUT)
/rp2350/~USB_BOOT: R7.2, SW1.2
GND: C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, IC1.4 (GND), J4.5 (GND), J4.6 (Shield), R6.2, SW1.1, U2.1 (GND), U3.47 (VREG_PGND), U3.61 (GND), Y1.2 (GND_1), Y1.4 (GND_2); also elsewhere on the board
unnamed: D1.2 (A), J4.1 (VBUS)
unnamed: IC1.1 (~CS), R1.1, R2.2, R3.1
unnamed: R6.1, SW2.1
unnamed: SW2.2, U3.26 (RUN)
unnamed: R9.2, U3.51 (USB_DM)
unnamed: R8.2, U3.52 (USB_DP)
unnamed: C11.1, R5.1, U3.46 (VREG_AVDD)
unnamed: L1.2, U3.48 (VREG_LX)
unnamed: C7.1, R4.2, Y1.3 (CRYSTAL_2)

Notes on the sheet:
power

Parts:
C1: 100n; C_0402_1005Metric
U8: SDP32-125PA-TR-250PCS; SDP32

Connections:
+3V3: C1.2, U8.7 (VDD); also elsewhere on the board
/SCL: U8.5 (SCL); also elsewhere on the board
/SDA: U8.8 (SDA); also elsewhere on the board
GND: C1.1, U8.1 (GND), U8.2 (GND), U8.3 (GND), U8.6 (GND), U8.9 (ADDR), U8.10 (GND), U8.11 (GND), U8.17 (EPAD), U8.18 (EPAD); also elsewhere on the board

Parts:
C28: 100n; C_0402_1005Metric
R14: 2.7k; R_0201_0603Metric
U5: SDP32-125PA-TR-250PCS; SDP32

Connections:
+3V3: C28.2, U5.7 (VDD); also elsewhere on the board
/SCL: U5.5 (SCL); also elsewhere on the board
/SDA: U5.8 (SDA); also elsewhere on the board
GND: C28.1, R14.2, U5.1 (GND), U5.2 (GND), U5.3 (GND), U5.6 (GND), U5.10 (GND), U5.11 (GND), U5.17 (EPAD), U5.18 (EPAD); also elsewhere on the board
unnamed: R14.1, U5.9 (ADDR)

Parts:
C2: 100n; C_0402_1005Metric
R15: 1.2k; R_0201_0603Metric
U1: SDP32-125PA-TR-250PCS; SDP32

Connections:
+3V3: C2.2, U1.7 (VDD); also elsewhere on the board
/SCL: U1.5 (SCL); also elsewhere on the board
/SDA: U1.8 (SDA); also elsewhere on the board
GND: C2.1, R15.2, U1.1 (GND), U1.2 (GND), U1.3 (GND), U1.6 (GND), U1.10 (GND), U1.11 (GND), U1.17 (EPAD), U1.18 (EPAD); also elsewhere on the board
unnamed: R15.1, U1.9 (ADDR)

Parts:
C23, C25: 22p; C_0603_1608Metric
C24: 10μF; C_0805_2012Metric
C26, C27: 100n; C_0603_1608Metric
IC2: TJA1050T; SOIC127P600X175-8N; Manufacturer_Part_Number TJA1050T; Mouser Part Number N/A
J6: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
R11: 10k; R_0603_1608Metric
R12: DNF; R_0603_1608Metric
R13: 120; R_0603_1608Metric
U4: MCP2515-xSO; SOIC-18W_7.5x11.6mm_P1.27mm
Y2: ABLS-8.000MHZ-12-B-4-Y-T; ABLS8000MHz12B4YT; Manufacturer_Part_Number ABLS-8.000MHZ-12-B-4-Y-T; Mouser Part Number 815-LS8000MHZ12B4YT

Connections:
+5V: C24.1, C26.1, C27.2, IC2.3 (VCC), R11.2, U4.18 (VDD); also elsewhere on the board
/CAN/RXCAN: IC2.4 (RXD), U4.2 (RXCAN)
/CAN/TXCAN: IC2.1 (TXD), U4.1 (TXCAN)
/CAN_H: IC2.7 (CANH), J6.2, R12.1; also elsewhere on the board
/CAN_L: IC2.6 (CANL), J6.1, R13.2; also elsewhere on the board
/CS: U4.16 (~CS); also elsewhere on the board
/INT: U4.12 (~INT); also elsewhere on the board
/MISO: U4.15 (SO); also elsewhere on the board
/MOSI: U4.14 (SI); also elsewhere on the board
/SCK: U4.13 (SCK); also elsewhere on the board
GND: C23.2, C24.2, C25.2, C26.2, C27.1, IC2.2 (GND), IC2.8 (S), U4.9 (VSS); also elsewhere on the board
unnamed: R12.2, R13.1
unnamed: C25.1, U4.8 (OSC1), Y2.2
unnamed: C23.1, U4.7 (OSC2), Y2.1
unnamed: R11.1, U4.17 (~RESET)

Notes on the sheet:
水晶発振子を使うこと。

Board: 2 copper layers, 48.1 x 68.1 mm, 67 parts (0 on the bottom side), 45 nets.

## KiCad design GPS/GPS/GPS.kicad_pcb

Parts:
BT1: ML414; SEIKO_ML414H_IV01E
C1, C4: 1u; C_0603_1608Metric
C2: 10n; C_0603_1608Metric
C3: 47p; C_0603_1608Metric
D1, D3: D; D_SMA
D2: D; L_0603_1608Metric
FB1: BLM18AG102SN1D; BLM18SP221SN1B; Manufacturer_Part_Number BLM18AG102SN1D; Mouser Part Number 81-BLM11A102S
IC1: NCP1117ST50T3G; SOT-223-3_TabPin2; Manufacturer_Part_Number NCP1117ST50T3G; Mouser Part Number 863-NCP1117ST50T3G
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HCTL_HC-TYPE-C-16P-01A
J2: CON-SMA-EDGE-S; RFSOLUTIONS_CON-SMA-EDGE-S; PARTREV 1
J3: Conn_01x06; JST_XH_B6B-XH-AM_1x06_P2.50mm_Vertical
R1: 100k; R_0603_1608Metric
R2, R3: 27; R_0402_1005Metric
R4, R5, R6, R7, R11: 33; R_0402_1005Metric
R8, R9: 5.1k; R_0603_1608Metric
R10: 3.3k; R_0603_1608Metric
R12: 220; R_0603_1608Metric
U1: NEO-M9N; ublox_NEO

Connections:
+3V3: D1.1 (K), D3.2 (A), J3.2, R1.1, U1.7 (VDD_USB), U1.23 (VCC)
/CS: J3.6, R6.2
/D+: J1.A6 (D+), J1.B6 (D+), R3.2
/D-: J1.A7 (D-), J1.B7 (D-), R2.2
/GPS_ANT1: FB1.1, J2.1, U1.11 (RF_IN)
/MISO: J3.5, R4.2
/MOSI: J3.4, R5.2
/RESET: U1.8 (~RESET)
/SCK: J3.3, R7.2
/VCC_RF: R11.2, U1.9 (VCC_RF)
/battery: BT1.1 (+), C1.1, R10.1, U1.22 (V_BCKP)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, IC1.1 (ADJUST/GROUND), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.G1, J2.G2, J2.G3, J2.G4, J3.1, R1.2, R8.1, R9.1, R12.1, U1.2 (D_SEL), U1.10 (GND), U1.12 (GND), U1.13 (GND), U1.24 (GND)
unnamed: C2.1, C3.1, C4.1, FB1.2, R11.1
unnamed: D1.2 (A), IC1.2 (OUTPUT_1), IC1.4 (OUTPUT_2)
unnamed: D2.2 (A), U1.3 (TIMEPULSE)
unnamed: D2.1 (K), R12.2
unnamed: D3.1 (K), R10.2
unnamed: J1.A5 (CC1), R8.2
unnamed: J1.B5 (CC2), R9.2
unnamed: R5.1, U1.21 (RXD/SPI_MOSI)
unnamed: R7.1, U1.19 (SCL/SPI_CLK)
unnamed: R6.1, U1.18 (SDA/~SPI_CS)
unnamed: R4.1, U1.20 (TXD/SPI_MISO)
unnamed: R2.1, U1.5 (USB_DM)
unnamed: R3.1, U1.6 (USB_DP)
VBUS: IC1.3 (INPUT), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)

Board: 2 copper layers, 38.6 x 37.4 mm, 26 parts (0 on the bottom side), 25 nets.

## KiCad design power/power.kicad_pcb

Parts:
C1, C2, C3, C4: 100n; C_0805_2012Metric
J1: ELE; JST_VH_B3P-VH-B_1x03_P3.96mm_Vertical
J2: LAD; JST_VH_B3P-VH-B_1x03_P3.96mm_Vertical
J3: RJ45_logger; RJ45_Amphenol_RJHSE538X
J4: PIROT; JST_XH_B5B-XH-AM_1x05_P2.50mm_Vertical
J5: Conn_01x06; JST_XH_B6B-XH-AM_1x06_P2.50mm_Vertical
J6: R_HAT_GEAR; JST_XH_B6B-XH-AM_1x06_P2.50mm_Vertical
J7: PWM_SPARE1; JST_VH_B3P-VH-B_1x03_P3.96mm_Vertical
J8: RJ45_base; RJ45_Amphenol_RJHSE538X
J9: L_HAT_GEAR; JST_XH_B6B-XH-AM_1x06_P2.50mm_Vertical
J10: PWM_SPARE2; JST_VH_B3P-VH-B_1x03_P3.96mm_Vertical
J11: RJ45_tail; RJ45_Amphenol_RJHSE538X

Connections:
+3V3: J4.1, J5.5; also elsewhere on the board
+8V: C1.2, C2.2, C3.2, C4.2, J1.2, J2.2, J6.2, J6.5, J7.2, J9.2, J9.5, J10.2; also elsewhere on the board
/5V_base: J8.4, J8.6, J8.8; also elsewhere on the board
/5V_logger: J3.4, J3.6, J3.8; also elsewhere on the board
/5V_tail: J11.4, J11.6, J11.8; also elsewhere on the board
/CAN_H: J3.1, J8.1, J11.1; also elsewhere on the board
/CAN_L: J3.2, J8.2, J11.2; also elsewhere on the board
/CS: J5.1; also elsewhere on the board
/ELE: J1.1; also elsewhere on the board
/ELE_ADC: J4.2; also elsewhere on the board
/LAD: J2.1; also elsewhere on the board
/LAD_ADC: J4.3; also elsewhere on the board
/L_GEAR: J9.1; also elsewhere on the board
/L_HAT: J9.4; also elsewhere on the board
/MISO: J5.2; also elsewhere on the board
/MOSI: J5.3; also elsewhere on the board
/PWM_SPARE1: J7.1; also elsewhere on the board
/PWM_SPARE2: J10.1; also elsewhere on the board
/P_switch: J4.4; also elsewhere on the board
/R_GEAR: J6.1; also elsewhere on the board
/R_HAT: J6.4; also elsewhere on the board
/SCK: J5.4; also elsewhere on the board
GND: C1.1, C2.1, C3.1, C4.1, J1.3, J2.3, J3.3, J3.5, J3.7, J3.SH, J4.5, J5.6, J6.3, J6.6, J7.3, J8.3, J8.5, J8.7, J8.SH, J9.3, J9.6, J10.3, J11.3, J11.5, J11.7, J11.SH; also elsewhere on the board
